<?xml version="1.0" encoding="UTF-8"?>
<workspace>   
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32F031CBT6_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32L073PF_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32SPIN27PF_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32F031C6T6_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32SPIN05PF_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32F003TW_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32F032R8T6_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32L062PF_BOOT_UART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\01_Bootloader_UART\EWARM\MM32SPIN06PF_BOOT_UART.ewp</path>
    </project>
    <batchBuild />
</workspace>
