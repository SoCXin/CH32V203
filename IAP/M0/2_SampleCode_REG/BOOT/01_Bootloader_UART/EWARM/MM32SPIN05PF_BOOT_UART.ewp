# IAR project MM32SPIN05PF_BOOT_UART.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN05PF MindMotion MM32SPIN05PF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; MM32SPIN05_Q; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\3_Device\CMSIS\IAR_CORE; ..\..\..\..\3_Device\MM32SPIN0x_q\Include; ..\Peripheral\inc; ..\TOOL\inc; ..\APP\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM32SPIN05_Q
  AARM.AUserIncludes: ..\APP\inc
  OBJCOPY.OOCOutputFile: MM32SPIN05PF_BOOT_UART.hex
  ILINK.IlinkOutputFile: MM32SPIN05PF_BOOT_UART.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\MindMotion\MM32SPIN05PF.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: ascii.c binary.c m0_isr_redefine.c main.c xmodem.c ymodem.c
  group Peripheral
    ../Peripheral/: flash.c tim3.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../3_Device/MM32SPIN0x_q/Source/IAR_StartAsm/: startup_BOOT_MM32SPIN0x_q.s
  group TOOL
    ../TOOL/: check.c queue.c
