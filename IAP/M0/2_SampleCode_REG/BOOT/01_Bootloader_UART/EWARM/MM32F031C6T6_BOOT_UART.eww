<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MM32F031C6T6_BOOT_UART.ewp</path>
    </project>
    <batchBuild />
</workspace>
