<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MM32L073PF_BOOT_UART.ewp</path>
    </project>
    <batchBuild />
</workspace>
