# IAR project MM32SPIN27PF_APP_DEFAULT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PF MindMotion MM32SPIN27PF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; MM32SPIN27_P; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\3_Device\CMSIS\IAR_CORE; ..\..\..\..\3_Device\MM32SPIN2xx_p\HAL_lib\inc; ..\..\..\..\3_Device\MM32SPIN2xx_p\Include; ..\Peripheral\inc; ..\BSP\inc; ..\APP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM32SPIN27_P
  AARM.AUserIncludes: ..\APP\inc
  OBJCOPY.OOCOutputFile: MM32SPIN27PF_APP_DEFAULT.hex
  ILINK.IlinkOutputFile: MM32SPIN27PF_APP_DEFAULT.out
  ILINK.IlinkIcfFile: ..\APP\MM32SPIN27PF_APP_Default.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: bsp_led.c
  group HAL_LIB
    ../../../../3_Device/MM32SPIN2xx_p/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group Peripheral
    ../Peripheral/: flash.c systick.c tim1.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../3_Device/MM32SPIN2xx_p/Source/IAR_StartAsm/: startup_APP_MM32SPIN2xx_p.s
    ../../../../3_Device/MM32SPIN2xx_p/Source/: system_MM32SPIN2xx_p.c
