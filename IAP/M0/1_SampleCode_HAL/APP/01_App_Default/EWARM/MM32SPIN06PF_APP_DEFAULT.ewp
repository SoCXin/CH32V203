# IAR project MM32SPIN06PF_APP_DEFAULT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN06PF MindMotion MM32SPIN06PF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; MM32SPIN06XX_S; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\3_Device\CMSIS\IAR_CORE; ..\..\..\..\3_Device\MM32SPIN06xx_s\HAL_lib\inc; ..\..\..\..\3_Device\MM32SPIN06xx_s\Include; ..\Peripheral\inc; ..\BSP\inc; ..\APP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM32SPIN06XX_S
  AARM.AUserIncludes: ..\APP\inc
  OBJCOPY.OOCOutputFile: MM32SPIN06PF_APP_DEFAULT.bin
  ILINK.IlinkOutputFile: MM32SPIN06PF_APP_DEFAULT.out
  ILINK.IlinkIcfFile: ..\APP\MM32SPIN06PF_APP_Default.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: bsp_led.c
  group HAL_LIB
    ../../../../3_Device/MM32SPIN06xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group Peripheral
    ../Peripheral/: flash.c systick.c tim1.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../3_Device/MM32SPIN06xx_s/Source/IAR_StartAsm/: startup_APP_mm32spin06xx_s_iar.s
    ../../../../3_Device/MM32SPIN06xx_s/Source/: system_mm32spin06xx_s.c
