# IAR project MM32F032R8T6_BOOT_UART.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F032R8T6 MindMotion MM32F032R8T6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; MM32F032_S; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\3_Device\CMSIS\IAR_CORE; ..\..\..\..\3_Device\MM32F032xx_s\HAL_lib\inc; ..\..\..\..\3_Device\MM32F032xx_s\Include; ..\Peripheral\inc; ..\TOOL\inc; ..\APP\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM32F032_S
  AARM.AUserIncludes: ..\APP\inc
  OBJCOPY.OOCOutputFile: MM32F032R8T6_BOOT_UART.hex
  ILINK.IlinkOutputFile: MM32F032R8T6_BOOT_UART.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\MindMotion\MM32F032x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: ascii.c binary.c m0_isr_redefine.c main.c xmodem.c ymodem.c
  group HAL_LIB
    ../../../../3_Device/MM32F032xx_s/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_crc.c HAL_dbg.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_ver.c HAL_wwdg.c
  group Peripheral
    ../Peripheral/: flash.c tim3.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../3_Device/MM32F032xx_s/Source/IAR_StartAsm/: startup_BOOT_MM32F032xx_s_IAR.s
  group TOOL
    ../TOOL/: check.c queue.c
