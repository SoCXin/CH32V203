<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MM32F032R8T6_APP_DEFAULT.ewp</path>
    </project>
    <batchBuild />
</workspace>
