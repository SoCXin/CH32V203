<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MM32SPIN27PF_APP_DEFAULT.ewp</path>
    </project>
    <batchBuild />
</workspace>
