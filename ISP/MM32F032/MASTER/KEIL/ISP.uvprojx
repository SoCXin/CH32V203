# Keil uVision project ISP.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F032C8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\MM32F032xx_s\Include;..\..\Device\MM32F032xx_s\HAL_Lib\Inc;..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\SYSTEM\MODULE;..\HARDWARE\UART;..\HARDWARE\LED;..\HARDWARE\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../Device/MM32F032xx_s/Source/: system_mm32f032xx_s.c
    ../../Device/MM32F032xx_s/Source/KEIL_StartAsm/: startup_mm32f032xx_s_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/MODULE/: module.c
  group USER
    ../USER/: main.c isp.c target_flash_code.h
  group HAL_Lib
    ../../Device/MM32F032xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_crc.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
